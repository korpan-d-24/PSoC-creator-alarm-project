# Keil uVision project Lab3_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(0) MODDP2"
  output: Lab3_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: CODE RU RC(10) IX CL(XDATA(X:0x0000-X:0x1FFF)) CL(CODE(C:0x0000-C:0xFFFF)) CL(CONST(C:0x0000-C:0xFFFF))
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h LCD_BarGraph.c LCD.c LCD.h LCD_PM.c Pin_1.c Pin_1.h Pin_1_aliases.h Pin_2.c Pin_2.h Pin_2_aliases.h LCD_LCDPort.c LCD_LCDPort.h LCD_LCDPort_aliases.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc cy_em_eeprom.c cy_em_eeprom.h project.h cycodeshareimport.ld cycodeshareexport.ld cycodeshareimport.scat CapSense.c CapSense.h CapSense_CSHL.c CapSense_CSHL.h CapSense_INT.c CapSense_Pins.c CapSense_Pins.h CapSense_PM.c CapSense_SMS_Wrapper.c CapSense_TunerHelper.c CapSense_TunerHelper.h CapSense_IntClock.c CapSense_IntClock.h CapSense_CompCH0.c CapSense_CompCH0.h CapSense_CompCH0_PM.c CapSense_AMuxCH0.c CapSense_AMuxCH0.h CapSense_IdacCH0.c CapSense_IdacCH0.h CapSense_IdacCH0_PM.c
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(0) MODDP2"
  output: Lab3_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: as above
